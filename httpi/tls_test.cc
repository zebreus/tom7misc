
#include "tls.h"

#include <initializer_list>
#include <span>
#include <string>
#include <variant>
#include <vector>

#include "crypt/aes.h"
#include "ansi.h"
#include "arcfour.h"
#include "base/logging.h"
#include "base/print.h"
#include "packet-parser.h"

#define CHECK_SOME(opt) ([&]{                          \
      auto o = (opt);                                  \
      CHECK(o.has_value()) << #opt << " was nullopt."; \
      return o.value();                                \
    }())

static void TestParseClientHello() {
  // Example ClientHello from tls12.xargs.org
  static constexpr uint8_t EXAMPLE[] = {
    // TLS Record header
    // 0x16, 0x03, 0x01, 0x00, 0xa5,
    // ClientHello
    0x01, 0x00, 0x00, 0xa1, 0x03, 0x03, 0x00, 0x01, 0x02, 0x03, 0x04,
    0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
    0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a,
    0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x00, 0x00, 0x20, 0xcc, 0xa8, 0xcc,
    0xa9, 0xc0, 0x2f, 0xc0, 0x30, 0xc0, 0x2b, 0xc0, 0x2c, 0xc0, 0x13,
    0xc0, 0x09, 0xc0, 0x14, 0xc0, 0x0a, 0x00, 0x9c, 0x00, 0x9d, 0x00,
    0x2f, 0x00, 0x35, 0xc0, 0x12, 0x00, 0x0a, 0x01, 0x00, 0x00, 0x58,
    0x00, 0x00, 0x00, 0x18, 0x00, 0x16, 0x00, 0x00, 0x13, 0x65, 0x78,
    0x61, 0x6d, 0x70, 0x6c, 0x65, 0x2e, 0x75, 0x6c, 0x66, 0x68, 0x65,
    0x69, 0x6d, 0x2e, 0x6e, 0x65, 0x74, 0x00, 0x05, 0x00, 0x05, 0x01,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x0a, 0x00, 0x0a, 0x00, 0x08, 0x00,
    0x1d, 0x00, 0x17, 0x00, 0x18, 0x00, 0x19, 0x00, 0x0b, 0x00, 0x02,
    0x01, 0x00, 0x00, 0x0d, 0x00, 0x12, 0x00, 0x10, 0x04, 0x01, 0x04,
    0x03, 0x05, 0x01, 0x05, 0x03, 0x06, 0x01, 0x06, 0x03, 0x02, 0x01,
    0x02, 0x03, 0xff, 0x01, 0x00, 0x01, 0x00, 0x00, 0x12, 0x00, 0x00,
  };

  TLS::ClientHello hello =
    CHECK_SOME(TLS::ParseClientHello(PacketParser(EXAMPLE)));

  for (int i = 0; i < 32; i++) {
    // The example packet uses a counting sequence.
    CHECK(hello.client_random[i] == i);
  }

  bool had_sni = false;
  for (const TLS::ClientHello::Extension &ext : hello.extensions) {
    if (const TLS::ServerNameIndication *sni =
        std::get_if<TLS::ServerNameIndication>(&ext)) {
      CHECK(!had_sni) << "Multiple SNI extensions?";
      CHECK(sni->hosts.size() == 1);

      had_sni = true;
    }
  }

  CHECK(had_sni) << "Didn't parse SNI extension";
}

static void TestPRF() {
  // For SHA-256.
  std::vector<uint8_t> secret = {
    0x9b, 0xbe, 0x43, 0x6b, 0xa9, 0x40, 0xf0, 0x17,
    0xb1, 0x76, 0x52, 0x84, 0x9a, 0x71, 0xdb, 0x35,
  };

  std::string label = "test label";

  std::vector<uint8_t> seed = {
    0xa0, 0xba, 0x9f, 0x93, 0x6c, 0xda, 0x31, 0x18,
    0x27, 0xa6, 0xf7, 0x96, 0xff, 0xd5, 0x19, 0x8c,
  };

  std::vector<uint8_t> expected_output = {
    0xe3, 0xf2, 0x29, 0xba, 0x72, 0x7b, 0xe1, 0x7b,
    0x8d, 0x12, 0x26, 0x20, 0x55, 0x7c, 0xd4, 0x53,
    0xc2, 0xaa, 0xb2, 0x1d, 0x07, 0xc3, 0xd4, 0x95,
    0x32, 0x9b, 0x52, 0xd4, 0xe6, 0x1e, 0xdb, 0x5a,
    0x6b, 0x30, 0x17, 0x91, 0xe9, 0x0d, 0x35, 0xc9,
    0xc9, 0xa4, 0x6b, 0x4e, 0x14, 0xba, 0xf9, 0xaf,
    0x0f, 0xa0, 0x22, 0xf7, 0x07, 0x7d, 0xef, 0x17,
    0xab, 0xfd, 0x37, 0x97, 0xc0, 0x56, 0x4b, 0xab,
    0x4f, 0xbc, 0x91, 0x66, 0x6e, 0x9d, 0xef, 0x9b,
    0x97, 0xfc, 0xe3, 0x4f, 0x79, 0x67, 0x89, 0xba,
    0xa4, 0x80, 0x82, 0xd1, 0x22, 0xee, 0x42, 0xc5,
    0xa7, 0x2e, 0x5a, 0x51, 0x10, 0xff, 0xf7, 0x01,
    0x87, 0x34, 0x7b, 0x66,
  };

  std::vector<uint8_t> actual_output(100);
  TLS::PRF(secret, label, seed, std::span<uint8_t>(actual_output));
  CHECK(expected_output == actual_output);
}

static void TestRoundTrip() {
  ArcFour rc("roundtrip");
  auto Randomize = [&rc](std::vector<uint8_t> *v) {
      for (int i = 0; i < v->size(); i++) {
        (*v)[i] = rc.Byte();
      }
    };

  static constexpr int MAC_KEY_SIZE = 20;
  static constexpr int ENC_KEY_SIZE = 32;
  static_assert(TLS::IV_SIZE == AES256::BLOCKLEN);
  std::vector<uint8_t> mac_key(MAC_KEY_SIZE, 0);
  std::vector<uint8_t> enc_key(ENC_KEY_SIZE, 0);

  // static constexpr int MAX_CONTENT_TEST = 1025;
  static constexpr int MAX_CONTENT_TEST = TLS::MAX_PLAINTEXT_SIZE;
  static_assert(MAX_CONTENT_TEST <= TLS::MAX_PLAINTEXT_SIZE);
  Print("Test round trip for {} sizes...\n", MAX_CONTENT_TEST);
  for (int content_len = 0;
       content_len < MAX_CONTENT_TEST;
       content_len++) {
    std::vector<uint8_t> content(content_len);
    Randomize(&content);
    Randomize(&mac_key);
    Randomize(&enc_key);

    const uint64_t seq = rc.Word64();
    constexpr TLS::ContentType type = TLS::APPLICATION_DATA;

    std::vector<uint8_t> iv(TLS::IV_SIZE);
    Randomize(&iv);

    std::vector<uint8_t> wire_data = TLS::MakeEncryptedRecord(
        mac_key, enc_key, seq, type, 3, 3, iv, content);

    // Simulate parsing record header.
    PacketParser pp(wire_data);
    CHECK(pp.size() >= 5);

    TLS::Record rec;
    rec.type = (TLS::ContentType)pp.Byte();
    rec.version_major = pp.Byte();
    rec.version_minor = pp.Byte();
    uint16_t length = pp.W16();

    CHECK(pp.size() == length);
    rec.fragment.resize(length);
    pp.BytesTo(length, rec.fragment.data());
    CHECK(pp.OK());

    auto result = TLS::DecryptRecord(mac_key, enc_key, seq, rec, true);

    CHECK(result.has_value()) << "Decryption failed for len " << content_len;

    std::span<const uint8_t> decrypted = result.value();

    CHECK(decrypted.size() == content_len);
    CHECK(0 == memcmp(decrypted.data(), content.data(), content_len));
  }

}

int main(int argc, char **argv) {
  ANSI::Init();

  TestParseClientHello();
  TestPRF();
  TestRoundTrip();

  Print("OK\n");
  return 0;
}
